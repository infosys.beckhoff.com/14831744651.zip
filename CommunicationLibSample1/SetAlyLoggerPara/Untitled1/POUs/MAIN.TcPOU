PROGRAM MAIN
VAR
	fbFile : FB_File;
	fbMqtt : FB_Mqtt;
	
	 {attribute 'TcAnalytics'}
	fTest : LREAL;
END_VAR

fTest := fTest + 0.1;
fbFile();
fbMqtt();

END_PROGRAM
